Commit message: added rotational element to replay

File: demos/rl_demo/resources/object_models/2v2_mod/2v2_mod_cylinder_small_alt.urdf (robot description, URDF)
Before this commit: robot 2v2_mod_cuboid_small, 1 links, 0 joints
Links:
- link 2v2_mod_cuboid_small: mass 0.1 -> 0.00001
